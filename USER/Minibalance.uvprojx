# Keil uVision project Minibalance.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BalanceCar
  c flags: Optim=1
  c define: STM32F10X_MD
  c include: ..\SYSTEM\sys;..\SYSTEM\delay;..\SYSTEM\usart;..\HARDWARE\led;..\HARDWARE\motor;..\HARDWARE\encoder;..\HARDWARE\IIC;..\HARDWARE\EXTI;..\HARDWARE\STMFLASH;..\BALANCE\control;..\BALANCE\MPU6050;..\BALANCE\filter;..\BALANCE\DMP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: startup_stm32f10x_md.s
  group USER
    ./: main.c
  group SYSTEM
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
  group HARDWARE
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/encoder/: encoder.c
    ../HARDWARE/IIC/: IOI2C.c
    ../HARDWARE/motor/: motor.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/led/: led.c
  group BALANCE
    ../BALANCE/MPU6050/: MPU6050.c
    ../BALANCE/control/: control.c
    ../BALANCE/filter/: filter.c
    ../BALANCE/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
